# Keil uVision project PROJECT-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: PROJECT-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c i2c.c lcd.c source.c uart.c BH-1750.c lcd.h i2c1.c i2c1.h
